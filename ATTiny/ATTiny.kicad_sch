File: ATTiny/ATTiny.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: update
Other:
- removed sheet Power Section
- added sheet Instrument Input Section (input.kicad_sch)
